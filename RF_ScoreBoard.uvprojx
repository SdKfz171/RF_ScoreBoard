# Keil uVision project RF_ScoreBoard.uvprojx, settings and files
target RF_ScoreBoard (ARM-ADS)
  device: STM32L476RG STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: RF_ScoreBoard
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTWO_RAM_REGIONS -DTARGET_NUCLEO_L476RG -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti --split_sections -DTARGET_STM32L476xG -DDEVICE_PORTINOUT=1 -DTARGET_FF_MORPHO -DTARGET_STM32L476RG -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_FLASH=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DMBED_BUILD_TIMESTAMP=1531397490.05 --apcs=interwork -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTARGET_CORTEX -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DDEVICE_TRNG=1 -DTARGET_FAMILY_STM32 -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DTARGET_STM32L4 -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DUSBHOST_OTHER -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM
  c include: .;Adafruit_NeoPixel;Adafruit_NeoPixel/Examples;mbed/.;mbed/TARGET_NUCLEO_L476RG;mbed/TARGET_NUCLEO_L476RG/TARGET_STM;mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4;mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG;mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TARGET_NUCLEO_L476RG;mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/device;mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/device;mbed/TARGET_NUCLEO_L476RG/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-DUSBHOST_OTHER,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DTWO_RAM_REGIONS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_L476RG/TOOLCHAIN_ARM_STD/stm32l476xx.sct
  link misc: --show_full_path
  group Adafruit_NeoPixel
    Adafruit_NeoPixel/: led_strip_write_color.s PololuLedStrip.cpp PololuLedStrip.h
    Adafruit_NeoPixel/Examples/: LedStripGradient.cpp
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_L476RG/TOOLCHAIN_ARM_STD/: analogin_api.o analogin_device.o analogout_api.o analogout_device.o can_api.o flash_api.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_tick_16b.o hal_tick_32b.o i2c_api.o l4_retarget.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o serial_device.o sleep.o spi_api.o startup_stm32l476xx.o stm32l4xx_hal.o stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.o stm32l4xx_hal_can.o stm32l4xx_hal_can_legacy.o stm32l4xx_hal_comp.o stm32l4xx_hal_cortex.o stm32l4xx_hal_crc.o stm32l4xx_hal_crc_ex.o stm32l4xx_hal_cryp.o stm32l4xx_hal_cryp_ex.o stm32l4xx_hal_dac.o stm32l4xx_hal_dac_ex.o stm32l4xx_hal_dcmi.o stm32l4xx_hal_dfsdm.o stm32l4xx_hal_dfsdm_ex.o stm32l4xx_hal_dma.o stm32l4xx_hal_dma2d.o stm32l4xx_hal_dma_ex.o stm32l4xx_hal_dsi.o stm32l4xx_hal_firewall.o stm32l4xx_hal_flash.o stm32l4xx_hal_flash_ex.o stm32l4xx_hal_flash_ramfunc.o stm32l4xx_hal_gfxmmu.o stm32l4xx_hal_gpio.o stm32l4xx_hal_hash.o stm32l4xx_hal_hash_ex.o stm32l4xx_hal_hcd.o stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_irda.o stm32l4xx_hal_iwdg.o stm32l4xx_hal_lcd.o stm32l4xx_hal_lptim.o stm32l4xx_hal_ltdc.o stm32l4xx_hal_ltdc_ex.o stm32l4xx_hal_nand.o stm32l4xx_hal_nor.o stm32l4xx_hal_opamp.o stm32l4xx_hal_opamp_ex.o stm32l4xx_hal_ospi.o stm32l4xx_hal_pcd.o stm32l4xx_hal_pcd_ex.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_qspi.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rng.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_sai.o stm32l4xx_hal_sai_ex.o stm32l4xx_hal_sd.o stm32l4xx_hal_sd_ex.o stm32l4xx_hal_smartcard.o stm32l4xx_hal_smartcard_ex.o stm32l4xx_hal_smbus.o stm32l4xx_hal_spi.o stm32l4xx_hal_spi_ex.o stm32l4xx_hal_sram.o stm32l4xx_hal_swpmi.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_hal_tsc.o stm32l4xx_hal_uart.o stm32l4xx_hal_uart_ex.o stm32l4xx_hal_usart.o stm32l4xx_hal_usart_ex.o stm32l4xx_hal_wwdg.o stm32l4xx_ll_adc.o stm32l4xx_ll_comp.o stm32l4xx_ll_crc.o stm32l4xx_ll_crs.o stm32l4xx_ll_dac.o stm32l4xx_ll_dma.o stm32l4xx_ll_dma2d.o stm32l4xx_ll_exti.o stm32l4xx_ll_fmc.o stm32l4xx_ll_gpio.o stm32l4xx_ll_i2c.o stm32l4xx_ll_lptim.o stm32l4xx_ll_lpuart.o stm32l4xx_ll_opamp.o stm32l4xx_ll_pwr.o stm32l4xx_ll_rcc.o stm32l4xx_ll_rng.o stm32l4xx_ll_rtc.o stm32l4xx_ll_sdmmc.o stm32l4xx_ll_spi.o stm32l4xx_ll_swpmi.o stm32l4xx_ll_tim.o stm32l4xx_ll_usart.o stm32l4xx_ll_usb.o stm32l4xx_ll_utils.o stm_spi_api.o system_clock.o system_stm32l4xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    mbed/TARGET_NUCLEO_L476RG/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h spi_device.h
    mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32l476xx.h stm32l4xx.h system_stm32l4xx.h
    mbed/TARGET_NUCLEO_L476RG/TARGET_STM/: gpio_object.h mbed_rtx.h nvic_addr.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h serial_api_hal.h stm32_assert.h
    mbed/: mbed.h
    mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/: objects.h
    mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TARGET_NUCLEO_L476RG/: PeripheralNames.h PinNames.h
    mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/device/: stm32_hal_legacy.h stm32l4xx_hal.h stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.h stm32l4xx_hal_can_legacy.h stm32l4xx_hal_comp.h stm32l4xx_hal_conf.h stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.h stm32l4xx_hal_dcmi.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dfsdm_ex.h stm32l4xx_hal_dma.h stm32l4xx_hal_dma2d.h stm32l4xx_hal_dma_ex.h stm32l4xx_hal_dsi.h stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gfxmmu.h stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hash.h stm32l4xx_hal_hash_ex.h stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.h stm32l4xx_hal_ltdc.h stm32l4xx_hal_ltdc_ex.h stm32l4xx_hal_nand.h stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_ospi.h stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.h stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.h stm32l4xx_hal_sai_ex.h stm32l4xx_hal_sd.h stm32l4xx_hal_sd_ex.h stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.h stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.h stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.h stm32l4xx_ll_crs.h stm32l4xx_ll_dac.h stm32l4xx_ll_dma.h stm32l4xx_ll_dma2d.h stm32l4xx_ll_dmamux.h stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.h stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.h stm32l4xx_ll_usart.h stm32l4xx_ll_usb.h stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h
  group RF_ScoreBoard
    ./: main.cpp
    /tmp/tmpcbfGVw/: mbed_config.h
